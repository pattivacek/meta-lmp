require optee-os-fio.inc

PV = "3.10.0+git"
SRCREV = "d3b496e94ef9b3ae15d53bbfdc4087df169e2080"
SRCBRANCH = "3.10+fio+7ulp"
